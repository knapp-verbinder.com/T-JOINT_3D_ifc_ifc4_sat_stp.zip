Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: T-JOINT_D35_W45_2xSK 6x120_1xSK 10x200
Time: 2022-02-03T11:42:28+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: SK Schraube 10x200_ohne_Gewinde_22042020
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SK Schraube 6x120_ohne_Gewinde (2)
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: T-Joint_D35_W45
In: Default Building Storey
PredefinedType: ELEMENT
