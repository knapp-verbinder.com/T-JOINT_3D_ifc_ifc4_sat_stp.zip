Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: T-JOINT_D20_W45_SK-Schraube 6x100 mm
Time: 2022-02-02T10:28:14+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Rundzylinderscheibe_8er_Schraube_45_V3
In: Default Building Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SK_Schraube_6x100
In: Default Building Storey
PredefinedType: ELEMENT
