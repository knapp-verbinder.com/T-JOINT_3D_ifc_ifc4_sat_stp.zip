Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: T-JOINT D40_W30_2xSK 8x200_1xSK 10x 300
Time: 2022-02-04T10:07:45+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 mm
